# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\MALLOC;..\USMART;..\FWLIB\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\DM9000;..\LWIP\lwip-2.1.2\include;..\LWIP\lwip-2.1.2\include\compat;..\LWIP\lwip-2.1.2\include\lwip;..\LWIP\lwip-2.1.2\netif;..\LWIP\lwip-2.1.2\include\lwip\apps;..\LWIP\lwip-2.1.2\include\lwip\priv;..\LWIP\lwip-2.1.2\include\lwip\prot;..\LWIP\arch;..\LWIP;..\LWIP\app;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/DM9000/: dm9000.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP_APP
    ../LWIP/app/: lwip_comm.c LwipClient.c LwipUDP.c LwipServer.c
  group LWIP_API
    ../LWIP/lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_CORE
    ../LWIP/lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LWIP/lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP_NETIF
    ../LWIP/lwip-2.1.2/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LWIP_ARCH
    ../LWIP/arch/: ethernetif.c sys_arch.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
